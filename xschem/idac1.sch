v {xschem version=3.4.4 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {idac1cell.sym} -150 -40 0 0 {name=xcell[7..0]}
C {devices/lab_pin.sym} -300 -60 0 0 {name=p4 sig_type=std_logic lab=vin[6..0],VREF_IN
}
C {devices/lab_pin.sym} 0 -60 2 0 {name=p7 sig_type=std_logic lab=vin[7..0]
}
C {devices/lab_pin.sym} 0 -40 0 1 {name=p8 sig_type=std_logic lab=VOUT
}
C {devices/lab_pin.sym} -300 -40 0 0 {name=p12 sig_type=std_logic lab=VCMD[0..7]
}
C {devices/lab_pin.sym} -300 -20 2 1 {name=p9 sig_type=std_logic lab=VDD
}
C {devices/lab_pin.sym} -300 0 2 1 {name=p10 sig_type=std_logic lab=VSS
}
C {devices/ipin.sym} -540 30 0 0 { name=p3 lab=VSS }
C {devices/ipin.sym} -540 10 0 0 { name=p5 lab=VREF_IN }
C {devices/iopin.sym} -540 -10 0 1 { name=p6 lab=VOUT }
C {devices/iopin.sym} -540 -30 0 1 { name=p11 lab=VDD }
C {devices/ipin.sym} -540 -50 0 0 { name=p13 lab=VCMD7 }
C {devices/ipin.sym} -540 -70 0 0 { name=p14 lab=VCMD6 }
C {devices/ipin.sym} -540 -90 0 0 { name=p15 lab=VCMD5 }
C {devices/ipin.sym} -540 -110 0 0 { name=p16 lab=VCMD4 }
C {devices/ipin.sym} -540 -130 0 0 { name=p17 lab=VCMD3 }
C {devices/ipin.sym} -540 -150 0 0 { name=p18 lab=VCMD2 }
C {devices/ipin.sym} -540 -170 0 0 { name=p19 lab=VCMD1 }
C {devices/ipin.sym} -540 -190 0 0 { name=p20 lab=VCMD0 }
